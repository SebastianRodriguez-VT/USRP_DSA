options:
  parameters:
    author: Sebastian
    generate_options: hb
    id: SubbandFilterBank
    output_language: python
    title: Subband Filter Bank
  states: {}

blocks:
- name: ConstMult
  id: variable
  parameters:
    value: '50'
  states: {}
- name: Cuttoff
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: StartingFreq
  id: variable
  parameters:
    value: '1'
  states: {}
- name: SubbandSpacing
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: TransitionWidth
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4.8e6
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: (3 * SubbandSpacing) + Cuttoff
    interp: '1'
    low_cutoff_freq: (3 * SubbandSpacing) - Cuttoff
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: TransitionWidth
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: SubbandSpacing + Cuttoff
    interp: '1'
    low_cutoff_freq: SubbandSpacing - Cuttoff
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: TransitionWidth
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1_1
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: StartingFreq + Cuttoff
    interp: '1'
    low_cutoff_freq: StartingFreq + 600
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: TransitionWidth
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1_2
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: (2 * SubbandSpacing) + Cuttoff
    interp: '1'
    low_cutoff_freq: (2 * SubbandSpacing) - Cuttoff
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: TransitionWidth
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1_3
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: (4 * SubbandSpacing) + Cuttoff
    interp: '1'
    low_cutoff_freq: (4 * SubbandSpacing) - Cuttoff
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: TransitionWidth
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: ConstMult
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ConstMult
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: ConstMult
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1_2
  id: blocks_multiply_const_vxx
  parameters:
    const: ConstMult
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1_3
  id: blocks_multiply_const_vxx
  parameters:
    const: ConstMult
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_1_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}

connections:
- [band_pass_filter_1, '0', blocks_multiply_const_vxx_1_1, '0']
- [band_pass_filter_1_0, '0', blocks_multiply_const_vxx_1_1_0, '0']
- [band_pass_filter_1_1, '0', blocks_multiply_const_vxx_1_1_1, '0']
- [band_pass_filter_1_2, '0', blocks_multiply_const_vxx_1_1_2, '0']
- [band_pass_filter_1_3, '0', blocks_multiply_const_vxx_1_1_3, '0']
- [blocks_multiply_const_vxx_1_1, '0', pad_sink_3, '0']
- [blocks_multiply_const_vxx_1_1_0, '0', pad_sink_1, '0']
- [blocks_multiply_const_vxx_1_1_1, '0', pad_sink_0, '0']
- [blocks_multiply_const_vxx_1_1_2, '0', pad_sink_2, '0']
- [blocks_multiply_const_vxx_1_1_3, '0', pad_sink_4, '0']
- [pad_source_1_0, '0', band_pass_filter_1, '0']
- [pad_source_1_0, '0', band_pass_filter_1_0, '0']
- [pad_source_1_0, '0', band_pass_filter_1_1, '0']
- [pad_source_1_0, '0', band_pass_filter_1_2, '0']
- [pad_source_1_0, '0', band_pass_filter_1_3, '0']

metadata:
  file_format: 1
