options:
  parameters:
    author: Sebastian
    generate_options: qt_gui
    id: Sense_And_Avoid
    output_language: python
    title: Sense_And_Avoid
  states: {}

blocks:
- name: Freq_lvl
  id: variable_qtgui_range
  parameters:
    label: Freq_lvl
    start: '-1.0e6'
    step: '1000'
    stop: '-500e3'
    value: '-639e3'
  states: {}
- name: activate_txer_fhss
  id: variable_qtgui_chooser
  parameters:
    label: activate_txer_fhss
    label0: Activate
    num_opts: '1'
    option0: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4.8e6
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: epy_block_0_0
    function_args: activate_txer_fhss
    function_name: change_channel
    poll_rate: '1'
    value: '0'
  states: {}
- name: vol_lvl
  id: variable
  parameters:
    value: '0.0015'
  states: {}
- name: SubbandFilterBank_0
  id: SubbandFilterBank
  parameters: {}
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*math.pi*(5e3)/samp_rate
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.8'
    type: complex
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '0.4'
    type: complex
  states: {}
- name: blocks_add_const_vxx_2
  id: blocks_add_const_vxx
  parameters:
    const: '2'
    type: complex
  states: {}
- name: blocks_add_const_vxx_3
  id: blocks_add_const_vxx
  parameters:
    const: '1.6'
    type: complex
  states: {}
- name: blocks_add_const_vxx_4
  id: blocks_add_const_vxx
  parameters:
    const: '1.2'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_2
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_3
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_4
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_lvl
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/seb/Documents/TestingFreqHop/hairdryer.wav
    repeat: 'True'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_out(pmt.intern(\"freq\"))\n        self.centerFreq = 0.0\n        self.channel = 0\n\n    def work(self, activate_txer_fhss):\n        self.channel = (self.channel + 3)%8\n        if not activate_txer_fhss:\n            P_freq_cmd = pmt.cons(pmt.string_to_symbol(\"freq\"), pmt.from_double(0))\n            self.message_port_pub(pmt.intern(\"freq\"), output_items)\n            return\n        freq = self.channel * -200e3\n        output_items = pmt.cons(pmt.string_to_symbol(\"freq\"), pmt.from_double(freq))\n        self.message_port_pub(pmt.intern(\"freq\"), output_items)\n        return output_items\n\n    def change_channel(self, activate_txer_fhss):\n        self.channel = (self.channel + 1)%5\n        if not activate_txer_fhss:\n            P_freq_cmd = pmt.cons(pmt.string_to_symbol(\"freq\"), pmt.from_double(0))\n            self.message_port_pub(pmt.intern(\"freq\"), P_freq_cmd)\n            print(\"hello\")\n            print(activate_txer_fhss)\n            return\n        else:\n            print(\"changing to subband \" + str(self.channel))\n            freq = (self.channel * -200e3) + self.centerFreq\n            P_freq_cmd = pmt.cons(pmt.string_to_symbol(\"freq\"), pmt.from_double(freq))\n            self.message_port_pub(pmt.intern(\"freq\"), P_freq_cmd)\n            return 1\n\n\n"
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nimport time\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.float32, np.float32, np.float32, np.float32, np.float32],\n            out_sig=[np.float32, np.float32, np.float32, np.float32, np.float32]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n        self.counter  = 1\n        self.n        = 400000\n        self.bands    = 5\n        self.ActionsList = self.SelectOnlyContiguousBands(1)\n        self.intf     = [0] * self.bands\n        self.decision = [0] * self.bands\n        self.Reward   = 0\n\n\n    def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        output_items[0][:] = input_items[0] * self.example_param\n        output_items[1][:] = input_items[1] * self.example_param\n        output_items[2][:] = input_items[2] * self.example_param\n        output_items[3][:] = input_items[3] * self.example_param\n        output_items[4][:] = input_items[4] * self.example_param\n\n        if (output_items[0][0] < 0.77) or (output_items[0][0] > 0.85):\n            first = 1\n        else:\n            first = 0\n\n        if output_items[1][0] > 1.7:\n            second = 1\n        else:\n            second = 0\n\n        if output_items[2][0] > 2.46:\n            third = 1\n        else:\n            third = 0\n\n        if output_items[3][0] > 3.29:\n            fourth = 1\n        else:\n            fourth = 0\n\n\n        if output_items[4][0] > 4.10:\n            fifth = 1\n\n        else:\n            fifth = 0\n        #print(self.counter)\n        print(list([first, second, third, fourth, fifth]))\n\n        intf = list([first, second, third, fourth, fifth])\n        #decision = self.ThompsonSampling(intf) \n\n\n\n        return len(output_items[0])\n\n\n    def SelectOnlyContiguousBands(self, a):\n        return a + 2\n\n\n\n    def bi2de(self, number):\n        \"\"\"\n        Binary2Decimal\n            Python already has some built in functions that let you do this pretty fast. \n            I may just have to swap the order, this would be done by simply changing a \n            +1 to -1\n\n        Number: a list of 5 subbands representing either our action or interferer\n        \"\"\"\n        bi2string = ''.join([str(x) for x in number])\n        return int(bi2string, 2)\n\n\n\n    def de2bi(self, values, bands):\n        \"\"\"\n        Decimal2Binary\n        \"\"\"\n        valueList = list([x for x in range(0,(2**bands)-1)])\n        finalList = []\n\n        for value in valueList:\n            binary = format(value, 'b')\n            while len(binary) < bands:\n                binary = '0' + binary\n            tempList = list([int(x) for x in binary])\n\n            finalList.append(tempList)\n\n        return finalList\n\n\n\n\n    def CalculateReward(self, actionTaken, intfSeen): #(fullAct, state, bands)\n        \"\"\"                                           # (decision, intf, bands)\n        Take the input and compare it with the interferer seen.\n        \"\"\"\n        bFrac = 1/(self.bands)\n\n        cO         = self.intf\n        contigOpen = [1-value for value in self.intf]\n\n        stack   = np.add(np.array(cO), np.array(self.decision)) # change this to action\n                                                                # Taken Maybe idk yet\n        NumCols = sum([1 for value in stack if (value > 1)])\n        NB      = sum([value for value in self.decision]) # change this to actionTaken Maybe ######  \n\n        temp = [value == 1 for value in contigOpen]\n\n        f = np.argwhere(np.diff([False] + temp + [False]) == True)\n\n        \"\"\"\n        There must be a better way to do this in python, this feels really inefficient\n        \"\"\"\n        #####################################################################\n        tempFirst = np.array([list(f[x]) for x in range(1, len(f), 2)])\n        tempSecon = np.array([list(f[x]) for x in range(0, len(f), 2)])\n        subtraction = np.subtract(tempFirst, tempSecon)\n        #####################################################################\n\n        ix = np.argmax(subtraction)\n        m  = subtraction[ix]\n\n        runstart = f[(2*ix)]\n        longrun  = m\n        runEnd   = runstart + longrun\n\n        opt = [0] * self.bands\n        for i in range(int(runstart), int(runEnd)):\n            opt[i] = 1\n\n        BWdist = np.abs(longrun - NB)\n\n        if NumCols > 0:\n            self.Reward = 0\n        elif BWdist > 0:\n            self.Reward = 1 - (0.1 * BWdist)\n        else:\n            self.Reward = 1\n\n        if self.Reward < 0:\n            self.Reward = 0\n\n\n        return NumCols\n\n\n\n    def ThompsonSampling(self, intf):\n        allReward = 0\n        print(\"Hello\")\n        k = int((self.bands * (self.bands + 1)) / 2) # arms\n        print(\"hello\")\n        S = 2 ** (self.bands)\n        print(\"HELLO?`\")\n        \"\"\"\n        TODO: implement this function\n        \"\"\"\n        #ActionsList = SelectOnlyContiguousBands(de2bi([1:2^(bands)-1], bands))\n\n        \"\"\"     \n        ********************************************************************\n        \"\"\"\n\n\n        if self.bands > 10:\n            #intfA = np.zeros([len(intf[:,1]),(self.bands-10)])\n            #intf = [intf, intfA]\n            print(\"BAND ERROR DONT GO HERE YET\")\n            raise ValueError(\"Too many bands, don't do this yet\")\n\n        d  =  2                #dimensionality\n        B  =  np.identity(d)   #prior covariance\n        mu =  [0] * d          #prior mean\n        f  =  np.transpose([0] * d)  #prior update\n\n        cSteps = 10\n        plays  = np.zeros([k,S])\n        play2  = np.zeros([k,cSteps])\n\n        sumR   = np.zeros([k,S])\n        meanR  = np.zeros([k,S])\n        lastR  = np.zeros([k,S])\n\n        loss  = np.zeros([1,n])\n        col   = np.zeros([1,n])\n\n        context =  np.zeros([k,d])\n        armVal  =  np.zeros([k,1])\n\n        act        = np.zeros([n,bands])\n        reward     = np.zeros([n,1])\n        prevAct    = np.ones([1,bands])\n        expD       = np.zeros([k,1])\n        best       = np.zeros([n,1])\n        bestArm    = 21\n\n        collision       = np.zeros([n,1])\n        missedO         = np.zeros([n,1])\n        numSubsSelected = np.zeros([n,1])\n        state           = intf[1]\n        #print(state)\n        count = 1\n\n        \"\"\"\n        **************************************************************************\n        I think everything in between the stars should be implemented at the __init__ \n        section because how else would the function learn unless I constantly passed\n        the calculated values back to itself. This way the object keeps track of itself\n        **I think**\n\n        If it wasnt pre-initialized I believe that all these lists would have to be \n        stored in work and then recalled at ThompsonSampling(_,_,_,_,_,_,...) again\n        \"\"\"\n\n\n        \"\"\"\n        TODO: this comment\n        \"\"\"\n        #Sn = bi2de(flip(intf(1,:)))+1\n\n\n\n\n\n\n        \"\"\"#*****************************************************\n        Start the Function\n        \"\"\"#*****************************************************\n\n        for t in range(1,n-1):\n            #target_range(t+1)  = Vr*PRI(t+1)*t+Ro+cn(t+1);\n            theta = np.random.multivariate_normal(mu,np.linalg.inv(B))\n\n            #Calculate posterior index for each arm\n            for i in range(0,k-1):\n                if (plays(i,Sn) > 0):\n                    c1 = meanR[i,Sn] #mean(history(i,Sn,1:plays(i,Sn)));\n                    c2 = lastR[i,Sn] #history(i,Sn,plays(i,Sn));\n                else:\n                    c1 = np.random.uniform()\n                    c2 = np.random.uniform()\n\n                context[i,:] = [c1,c2] #arm specific context  \n                armVal[i] = np.dot(context[i,:],theta)\n\n            armVal = list(armVal)\n            bestArm = int(armVal.index(max(armVal))) #play arm with highest posterior index\n\n            \"\"\"#*****************************************************\n            TODO: this comment\n            \"\"\"#*****************************************************\n            #SnP = bi2de(flip(state))+1;\n            SnP = 9\n\n\n\n            prevState = state\n\n            state = intf[t+1]\n\n            if t == 1:\n                count = 1\n            elif prevState == state:\n                count = count+1\n            else :\n                count = 1\n\n            \"\"\"#*****************************************************\n            TODO: this comment\n            \"\"\"#*****************************************************\n            #Sn = bi2de(flip(state))+1;\n            Sn = 10\n\n\n\n\n\n            plays[bestArm,SnP] = plays[bestArm,SnP]+1\n\n            if count <= cSteps:\n                play2[bestArm,count] = play2[bestArm,count] + 1\n            else :\n                play2[bestArm,cSteps] = play2[bestArm,cSteps] + 1\n\n\n            best[t-1] = bestArm\n\n            fullAct = ActionsList[bestArm,:]\n            act[t,:] = fullAct\n\n            \"\"\"#*****************************************************\n             TODO: this comment\n            \"\"\"#*****************************************************\n            #collision[t] = CalculateReward(fullAct,state,bands);\n            reward[t] = 0\n\n\n\n            allReward = allReward + reward[t]\n\n\n            sumR[bestArm,SnP] = sumR[bestArm,SnP] + reward[t]\n            meanR[bestArm,SnP] = sumR[bestArm,SnP]/plays[bestArm,SnP];\n            lastR[bestArm,SnP] = reward[t];\n            prevAct = fullAct;\n\n            #Update posterior dist\n            B = B + np.transpose(context[bestArm,:])*context[bestArm,:]\n            f = f + np.transpose(context[bestArm,:])*reward[t]\n            mu = f/B\n\n            if t > 1:\n                loss[t] = loss[t-1] + (1-reward[t])\n                col[t]  = col[t-1]  + collision[t]\n\n\n        return 0\n\n\n\n\n\n\n"
    example_param: '2'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: '1'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: freq
    label: Frequency
    type: double
    value: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '2048'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: fff
  states: {}

connections:
- [SubbandFilterBank_0, '0', blocks_add_const_vxx_1, '0']
- [SubbandFilterBank_0, '1', blocks_add_const_vxx_0, '0']
- [SubbandFilterBank_0, '2', blocks_add_const_vxx_4, '0']
- [SubbandFilterBank_0, '3', blocks_add_const_vxx_3, '0']
- [SubbandFilterBank_0, '4', blocks_add_const_vxx_2, '0']
- [analog_frequency_modulator_fc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_complex_to_float_2, '0']
- [blocks_add_const_vxx_1, '0', blocks_complex_to_float_0, '0']
- [blocks_add_const_vxx_2, '0', blocks_complex_to_float_3, '0']
- [blocks_add_const_vxx_3, '0', blocks_complex_to_float_1, '0']
- [blocks_add_const_vxx_4, '0', blocks_complex_to_float_4, '0']
- [blocks_complex_to_float_0, '0', epy_block_1, '0']
- [blocks_complex_to_float_1, '0', epy_block_1, '3']
- [blocks_complex_to_float_2, '0', epy_block_1, '1']
- [blocks_complex_to_float_3, '0', epy_block_1, '4']
- [blocks_complex_to_float_4, '0', epy_block_1, '2']
- [blocks_multiply_const_vxx_1_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0_0, '0', SubbandFilterBank_0, '0']
- [blocks_throttle_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0_0, freq, qtgui_edit_box_msg_0, val]
- [epy_block_1, '0', qtgui_time_sink_x_1, '0']
- [epy_block_1, '1', qtgui_time_sink_x_1, '1']
- [epy_block_1, '2', qtgui_time_sink_x_1, '2']
- [epy_block_1, '3', qtgui_time_sink_x_1, '3']
- [epy_block_1, '4', qtgui_time_sink_x_1, '4']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [qtgui_edit_box_msg_0, msg, freq_xlating_fir_filter_xxx_0, freq]
- [rational_resampler_xxx_0, '0', analog_frequency_modulator_fc_0, '0']

metadata:
  file_format: 1
